# Keil uVision project STM3210E-EVAL_Demo.uvproj, settings and files
target STM3210E-EVAL_Demo (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL_Demo +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,USE_STM3210E_EVAL
  c include: ..\inc;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../src/: calendar.c hw_config.c i2s_codec.c lowpower.c main.c mass_mal.c mass_storage.c memory.c menu.c nand_if.c scsi_data.c smartcard.c stm32f10x_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c waveplayer.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group RVMDK
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../src/: system_stm32f10x.c
  group STM3210E_EVAL
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c stm3210e_eval_fsmc_nand.c stm3210e_eval_fsmc_nor.c stm3210e_eval_fsmc_sram.c stm3210e_eval_i2c_tsensor.c stm3210e_eval_lcd.c stm3210e_eval_sdio_sd.c stm3210e_eval_spi_flash.c
